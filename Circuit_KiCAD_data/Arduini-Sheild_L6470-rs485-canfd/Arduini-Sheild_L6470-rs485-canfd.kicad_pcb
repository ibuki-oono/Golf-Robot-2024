# Repository ibuki-oono/Golf-Robot-2024

File README.md:

# Gold Robot for Yamanashi-robocon 2024
This repository is containing CAD(Inventor file).

## KiCad design Circuit_KiCAD_data/Arduini-Sheild_L6470-rs485-canfd/Arduini-Sheild_L6470-rs485-canfd.kicad_pcb

Parts:
C1, C9, C10, C16, C22, C23: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2, C3: 22p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C4, C6, C8, C17, C19, C21: 0.01u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C5, C18: 0.22u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C7, C13, C14, C20, C26, C27: 100p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C11: 100u; CP_Elec_10x10.5
C12, C25: 47u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C15: 0.33u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1, D3: 3.6V; D_SOD-323_HandSoldering
D2, D4: BAV99; SOT-23-3
J1: Power; PinSocket_1x08_P2.54mm_Vertical
J2: Analog; PinSocket_1x06_P2.54mm_Vertical
J3: Digital/PWM; PinSocket_1x10_P2.54mm_Vertical
J4: Digital/PWM; PinSocket_1x08_P2.54mm_Vertical
J5: FeetechSTS; Molex_SPOX_5267-03A_1x03_P2.50mm_Vertical
J6: Jack-DC; BarrelJack_GCT_DCJ200-10-A_Horizontal
J7, J11: XH-4; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J8: PH-4; JST_PH_B4B-PH-K_1x04_P2.00mm_Vertical
J9, J10: XH-2; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
J12, J13: XH-4; JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal
J16, J17: PinHeader-4; PinHeader_1x04_P2.54mm_Vertical
Q1: 2SA1015; TO-92_Inline
Q2, Q3: Q_NMOS_GSD; SOT23GDS
R1: 7.5K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2: 20K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R4: 2.2K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5, R13: 33K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R6, R14: 8.2K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7, R15: NM/100R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R8, R9, R10, R16, R17, R18: 10K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R11, R12: 100R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RV1, RV2: 200K; GF063_VR
U1: MAX485E; SOIC-8_5.23x5.23mm_P1.27mm
U2: MCP2517FD-xSL; SOIC-14_3.9x8.7mm_P1.27mm
U3: MCP2542FD-E/SN; SOIC-8_3.9x4.9mm_P1.27mm
U4, U6: L6470H; HTSSOP-28-1EP_4.4x9.7mm_P0.65mm_EP3.4x9.5mm
U5: L7806; TO-263-2
Y1: 20MHz; Crystal_HC49-U_Vertical

Connections:
+3V0: C10.1, C12.1, C23.1, C25.1, R8.1, R9.1, R10.1, R16.1, R17.1, R18.1, U4.6 (VREG), U4.17 (VDD), U6.6 (VREG), U6.17 (VDD)
+5V: C1.1, J1.5, J8.1, J12.1, J13.1, J16.1, J17.1, Q1.1 (E), R3.1, U1.8 (VCC), U2.14 (VDD), U3.3 (VDD), U3.5 (VIO)
+6V: C16.1, J5.1, U5.3 (OUT)
/2OUT1A: J11.1, U6.1 (OUT1A)
/2OUT1B: J11.4, U6.14 (OUT1B)
/2OUT2A: J11.2, U6.28 (OUT2A)
/2OUT2B: J11.3, U6.15 (OUT2B)
/4: J4.4, U6.23 (*CS)
/7: J4.1, U4.23 (*CS)
/8: J3.10, U2.13 (nCS)
/12: J3.6, U2.12 (SDO), U4.18 (SDO), U6.18 (SDO)
/13: J3.5, U2.10 (SCK), U4.19 (CK), U6.19 (CK)
/*3: C13.1, J4.5, R9.2, U4.22 (*BUSY/SYNC)
/*5: J4.3
/*6: J4.2
/*9: J3.9, Q3.1 (G)
/*10: J3.8, Q2.1 (G)
/*11: J3.7, U2.11 (SDI), U4.20 (SDI), U6.20 (SDI)
/*BUSY2: C26.1, J4.6, R17.2, U6.22 (*BUSY/SYNC)
/*FLAG: C14.1, C27.1, R10.2, R18.2, U4.24 (*FLAG), U6.24 (*FLAG)
/*STBY: C7.1, C20.1, R8.2, R16.2, U4.3 (*STBY/*RST), U6.3 (*STBY/*RST)
/A0: J2.1, J16.3
/A1: J2.2, J17.3
/A2: J2.3
/A3: J2.4
/AREF: J3.3
/IOREF: J1.2
/OUT1A: J7.1, U4.1 (OUT1A)
/OUT1B: J7.4, U4.14 (OUT1B)
/OUT2A: J7.2, U4.28 (OUT2A)
/OUT2B: J7.3, U4.15 (OUT2B)
/RX/0: J4.8, U1.1 (RO)
/SCL/A5: J2.6, J3.1, J12.4, J13.4
/SDA/A4: J2.5, J3.2, J12.3, J13.3
/STCK: U4.25 (STCK), U6.25 (STCK)
/TX/1: J4.7, R1.1, U1.4 (DI)
/~RESET: J1.3
GND: C1.2, C2.1, C3.1, C4.2, C6.2, C7.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C19.2, C20.2, C22.2, C23.2, C25.2, C26.2, C27.2, D1.2 (A), D3.2 (A), J1.6, J1.7, J3.4, J5.3, J6.2, J8.4, J12.2, J13.2, J16.4, J17.4, Q2.2 (S), Q3.2 (S), R2.1, R4.2, R6.2, R7.1, R14.2, R15.1, U1.5 (GND), U2.7 (VSS), U3.2 (VSS), U3.8 (STBY), U4.9 (AGND), U4.13 (PGND), U4.21 (DGND), U4.27 (PGND), U4.29 (EPAD), U5.2 (GND), U6.9 (AGND), U6.13 (PGND), U6.21 (DGND), U6.27 (PGND), U6.29 (EPAD)
unnamed: C4.1, D1.1 (K), R6.1, RV1.2, RV1.3, U4.5 (ADCIN)
unnamed: C5.1, D2.2 (K), U4.11 (VBOOT)
unnamed: C8.1, D2.3 (common)
unnamed: C17.1, D3.1 (K), R14.1, RV2.2, RV2.3, U6.5 (ADCIN)
unnamed: C18.1, D4.2 (K), U6.11 (VBOOT)
unnamed: C21.1, D4.3 (common)
unnamed: J5.2, U1.6 (A)
unnamed: J8.2, U3.7 (CANH)
unnamed: J8.3, U3.6 (CANL)
unnamed: J9.1, R11.2
unnamed: J9.2, Q2.3 (D)
unnamed: J10.1, R12.2
unnamed: J10.2, Q3.3 (D)
unnamed: Q1.3 (B), R1.2
unnamed: Q1.2 (C), R2.2, U1.2 (~RE), U1.3 (DE)
unnamed: R5.2, RV1.1
unnamed: R13.2, RV2.1
unnamed: R3.2, R4.1, U1.7 (B)
unnamed: C3.2, U2.6 (OSC1), Y1.1
unnamed: C2.2, U2.5 (OSC2), Y1.2
unnamed: U2.2 (RXCAN), U3.4 (RXD)
unnamed: U2.1 (TXCAN), U3.1 (TXD)
unnamed: C8.2, U4.10 (CP)
unnamed: C6.1, R7.2, U4.4 (SW)
unnamed: C21.2, U6.10 (CP)
unnamed: C19.1, R15.2, U6.4 (SW)
VCC: J1.8
VS: C5.2, C9.1, C11.1, C15.1, C18.2, C22.1, D2.1 (A), D4.1 (A), J6.1, R5.1, R13.1, U4.2 (VSA), U4.12 (VSB), U4.16 (VSB), U4.26 (VSA), U5.1 (IN), U6.2 (VSA), U6.12 (VSB), U6.16 (VSB), U6.26 (VSA)

Notes on the sheet:
RS485通信系
canfd通信系
ステッピングモータードライブ回路
* Indicates a PWM-capable pin

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
Board: 2 copper layers, 68.6 x 53.3 mm, 79 parts (0 on the bottom side), 59 nets.

Other parts of the board:
MH1, MH2, MH3, MH4: MountingHole_3.2mm

## Commit log

2024-11-10 aborts
2024-11-10 change readme
2024-11-10 upload kicad file
